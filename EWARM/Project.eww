<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\APDS_9960.ewp</path>
  </project>
  <batchBuild />
</workspace>
